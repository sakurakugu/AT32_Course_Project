# Keil uVision project homework.uvprojx, settings and files
target homework (6230000::V6.23::ARMCLANG)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: homework +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=1
  c define: AT32F435VGT7, AT_START_F435_V1, USE_STDPERIPH_DRIVER,AT_SURF_F437_V1,HAVE_CONFIG_H,LV_LVGL_H_INCLUDE_SIMPLE, KEIL_COMPILE
  c include: .\lib\cJSON;.\lib\cmsis\cm4\core_support;.\lib\cmsis\cm4\device_support;.\lib\drivers\inc;.\lib\FreeRTOS\include;.\lib\FreeRTOS\portable\GCC\ARM_CM4F;.\lib\middlewares\i2c_application_library;.\lib\middlewares\3rd_party\fatfs\source;.\gui\lvgl;.\gui\custom;.\gui\generated\guider_customer_fonts;.\gui\generated\guider_fonts;.\gui\generated\images;.\gui\generated;.\src;.\src\app\weather;.\src\app\music;.\src\app\IoT;.\src\app\calculator;.\src\app\minecraft;.\src\app\setting;.\src\app\weather;.\src\board;.\src\board\eeprom;.\src\board\key;.\src\board\lcd;.\src\board\led;.\src\board\network;.\src\board\sensor;.\src\board\sound;.\src\board\uart;.\src\config;.\src\config\lvgl;.\src\config\lvgl\porting;.\src\util
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xb0000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group src
    src/: main.cpp
    ./src/: application.cpp
  group src/app
    ./src/app/calculator/: calculator.c
    ./src/app/IoT/: IoT.cpp
    ./src/app/setting/: setting.cpp
    ./src/app/music/: music.cpp
    ./src/app/weather/: weather_service.cpp
    ./src/app/minecraft/: minecraft.cpp
  group src/board
    ./src/board/: board.cpp bsp_queue.c timer.c bsp_ext_flash.c
    ./src/board/sensor/: lm75.cpp mpu6050.cpp adc_voltage.cpp
    ./src/board/uart/: uart.cpp
    ./src/board/key/: key.cpp
    ./src/board/lcd/: lcd.cpp touch.cpp
    ./src/board/led/: oled.cpp oled_font.cpp led.cpp color_led.cpp
    ./src/board/sound/: beep.cpp
    ./src/board/network/: wifi.cpp wifi.c
    ./src/board/eeprom/: eeprom.cpp
  group src/task
    ./src/task/: task_key.cpp task_wifi.cpp
  group src/util
    ./src/util/: delay.c
  group lib/firmware
    ./lib/drivers/src/: at32f435_437_crm.c at32f435_437_dma.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_xmc.c at32f435_437_scfg.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_exint.c at32f435_437_qspi.c at32f435_437_clock.c at32f435_437_int.c
  group lib/cmsis
    ./lib/cmsis/cm4/device_support/: system_at32f435_437.c
    ./lib/cmsis/: startup_at32f435_437.s
  group lib/freertos
    ./lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./lib/FreeRTOS/portable/MemMang/: heap_4.c
    ./lib/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group lib/other
    ./lib/cJSON/: cJSON.c
    ./lib/middlewares/i2c_application_library/: i2c_application.c
  group lvgl/src
    ./gui/lvgl/src/core/: lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c lv_disp.c
    ./gui/lvgl/src/draw/: lv_draw.c lv_draw_layer.c lv_draw_transform.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./gui/lvgl/src/extra/: lv_extra.c
    ./gui/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./gui/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./gui/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./gui/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./gui/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./gui/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./gui/lvgl/src/extra/widgets/led/: lv_led.c
    ./gui/lvgl/src/extra/widgets/list/: lv_list.c
    ./gui/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./gui/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./gui/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./gui/lvgl/src/extra/widgets/span/: lv_span.c
    ./gui/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./gui/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./gui/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./gui/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./gui/lvgl/src/extra/widgets/win/: lv_win.c
    ./gui/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./gui/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./gui/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./gui/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./gui/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./gui/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./gui/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./gui/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./gui/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./gui/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./gui/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./gui/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./gui/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./gui/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./gui/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./gui/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./gui/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./gui/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./gui/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./gui/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./gui/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./gui/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_layer.c lv_draw_sw_transform.c
    ./gui/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c
    ./gui/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c
    ./gui/lvgl/src/extra/widgets/carousel/: lv_carousel.c
    ./gui/lvgl/src/extra/widgets/dclock/: lv_dclock.c
  group lvgl/config
    ./src/config/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ./src/config/lvgl/: lv_tick_custom.c
    ./gui/custom/: custom.c
  group lvgl/gui
    ./gui/generated/: events_init.c gui_guider.c widgets_init.c setup_scr_calculator_app.c setup_scr_deepseek_app.c setup_scr_electronic_organ_app.c setup_scr_drawing_board_app.c setup_scr_minecraft_app.c setup_scr_link_game_app.c setup_scr_game3_app.c setup_scr_game5_app.c setup_scr_home_app1.c setup_scr_home_app2.c setup_scr_music_app.c setup_scr_setting_app.c setup_scr_smart_home_app.c setup_scr_status_app.c setup_scr_weather_app.c
  group lvgl/font
    ./gui/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_14.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c lv_font_montserratMedium_64.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_16.c
  group lvgl/picture
    ./gui/generated/images/: _calculator_app_alpha_80x80.c _color_led_alpha_80x80.c _drawing_app_alpha_80x80.c _electronic_organ_app_alpha_80x80.c _minecraft_icon_alpha_80x80.c _music_app_alpha_80x80.c _music_next_song_alpha_16x16.c _music_pause_alpha_16x16.c _music_player_alpha_16x16.c _music_prev_song_alpha_16x16.c _music_record_alpha_160x160.c _music_stylus_alpha_26x126.c _setting_app_alpha_80x80.c _smart_home_app_alpha_80x80.c _voice_off_alpha_16x16.c _voice_on_alpha_16x16.c _weather_app_alpha_80x80.c _wifi_alpha_16x16.c
  group docs
    ./: README.md
  group minecraft/texture
    ./src/app/minecraft/texture/: badapple.c chutou.c jntm.c liewen.c mapTextures.c
